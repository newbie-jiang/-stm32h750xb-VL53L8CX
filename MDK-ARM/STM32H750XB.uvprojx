# Keil uVision project STM32H750XB.uvprojx, settings and files
target STM32H750XB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H750XB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../BSP;../lib/shell/include;../lib/shell/cmd/all_cmd_interface;../lib/shell/cmd;../FreeRTOS-Kernel;../FreeRTOS-Kernel/include;../FreeRTOS-Kernel/portable/MemMang;../FreeRTOS-Kernel/portable/RVDS/ARM_CM7/r0p1;../RTOS_APP/creat_task;../RTOS_APP/task_app;../api;../application;;../Utilities/JPEG;../X-CUBE-TOF1/Target;../Drivers/BSP/Components/Common;../Drivers/BSP/53L8A1;../Drivers/BSP/Components/vl53l8cx/modules;../Drivers/BSP/Components/vl53l8cx/porting;../Drivers/BSP/Components/vl53l8cx;..\application\tof_app
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c dma2d.c fmc.c ltdc.c spi.c tim.c usart.c custom_bus.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group bsp
    ../BSP/: bsp_information.c bsp_key.c bsp_led.c bsp_sdram.c bsp_tick.c bsp_usart.c ring_buffer.c string.c
  group api
    ../api/: api_information.c api_led.c api_sdram.c api_uart.c
  group lib/shell
    ../lib/shell/src/: command.c exception.c parser.c shell.c
    ../lib/shell/cmd/: cmd_setenv.c cmd_reboot.c cmd_ram.c cmd_mem.c cmd_help.c cmd_go.c cmd_clear.c
    ../lib/shell/cmd/all_cmd_interface/: interface_cmd.c
  group application
    ../application/: app_cjson.c app_config.h
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/vl53l8cx/modules/: vl53l8cx_api.c vl53l8cx_plugin_detection_thresholds.c vl53l8cx_plugin_motion_indicator.c vl53l8cx_plugin_xtalk.c
    ../Drivers/BSP/Components/vl53l8cx/porting/: platform.c
    ../Drivers/BSP/Components/vl53l8cx/: vl53l8cx.c
  group Drivers/BSP/53L8A1
    ../Drivers/BSP/53L8A1/: 53l8a1_ranging_sensor.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../Drivers/BSP/53L8A1/: LICENSE.txt
    ../Drivers/BSP/Components/vl53l8cx/: LICENSE.txt
  group tof_app
    ../application/tof_app/: app_tof.c app_tof_pin_conf.c
software components: CMSIS:CORE 6.1.0
